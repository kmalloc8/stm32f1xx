<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32F103C8Tx-template-IAR-v7.ewp</path>
  </project>
  <batchBuild />
</workspace>
